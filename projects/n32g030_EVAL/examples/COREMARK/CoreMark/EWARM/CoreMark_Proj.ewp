# IAR project CoreMark_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G030C8 Nations N32G030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G030; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\coremark; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CoreMark_Proj.bin
  ILINK.IlinkOutputFile: CoreMark_Proj.out
  ILINK.IlinkIcfFile: D:\WorkSpace\N_WorkSpace\NS3603-1A\Nationstech.N32G030_Library.1.0.0\projects\n32g030_EVAL\examples\COREMARK\CoreMark\EWARM\N32G030x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../src/: readme.txt
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_crc.c n32g030_flash.c n32g030_gpio.c n32g030_rcc.c n32g030_usart.c
  group STARTUP
    ../startup/: startup_n32g030_EWARM.S
  group USER
    ../src/: main.c n32g030_it.c
